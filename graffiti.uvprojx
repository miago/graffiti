# Keil uVision project graffiti.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTX_Starter
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, GLCD_DEVICE_STM32F10X, GLCD_CONTROLLER_ST7565R, GLCD_LCD_WIDTH=128, GLCD_LCD_HEIGHT=32, GLCD_INIT_NHD_C12832A1Z_FSW_FBW_3V3
  c include: .\inc\alia;.\inc\app;.\inc\hal;.\glcd;.\glcd\fonts;.\inc\tasks
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group general
    ./src/: main.c
    ./src/alia/: display.c alia.c text_generator.c
  group app
    ./src/app/: joystick_app.c laser_app.c servos_app.c controller_app.c display_app.c
  group hal
    ./src/hal/: joystick_hal.c laser_hal.c servos_hal.c
  group tasks
    ./src/tasks/: laser_task.c controller_task.c joystick_task.c servos_task.c display_task.c
  group glcd
    ./glcd/: glcd.c graphics.c graphs.c text.c text_tiny.c
    ./glcd/controllers/: ST7565R.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
